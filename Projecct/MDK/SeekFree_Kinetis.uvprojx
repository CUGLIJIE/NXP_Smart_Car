# Keil uVision project SeekFree_Kinetis.uvprojx, settings and files
target SeekFree_MK60DN (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MK60DN512xxx10 Freescale
  pack: Keil.Kinetis_K60_DFP.1.0.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: SeekFree_Kinetis +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MK60DN
  c include: ..\USER\inc;..\USER\src;..\..\Libraries\startup\CoreSupport;..\..\Libraries\startup\DeviceSupport\MDK-ARM;..\..\Libraries\startup\DeviceSupport;..\..\Libraries\drives\inc;..\..\Libraries\drives\src;..\..\Libraries\seekfree;..\..\Libraries\FatFs;..\..\Libraries\FatFs\option;..\Self\inc;..\Self\src
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x20000
  group startup
    ../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK60F15.s startup_MK60D10.s
    ../../Libraries/startup/DeviceSupport/: system_MK60.c
  group drives_h
    ../../Libraries/drives/inc/: common.h headfile.h misc.h MK60_cmt.h MK60_dma.h MK60_flash.h MK60_ftm.h MK60_gpio.h MK60_i2c.h MK60_lptmr.h MK60_pit.h MK60_port.h MK60_port_cfg.h MK60_rtc.h MK60_systick.h MK60_uart.h MK60_wdog.h MK60_sdhc.h
  group drives_c
    ../../Libraries/drives/src/: common.c misc.c MK60_cmt.c MK60_dma.c MK60_flash.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_pit.c MK60_port.c MK60_rtc.c MK60_systick.c MK60_uart.c MK60_wdog.c MK60_sdhc.c
  group user_h
    ../USER/inc/: isr.h
    ../../Libraries/drives/inc/: headfile.h
  group user_c
    ../USER/src/: isr.c main.c
  group seekfree
    ../../Libraries/seekfree/: SEEKFREE_FUN.c SEEKFREE_FUN.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_MT9V032.c SEEKFREE_MT9V032.h SEEKFREE_OLED.c SEEKFREE_OLED.h font.c font.h
  group fatfs
    ../../Libraries/FatFs/: 00readme.txt diskio.c diskio.h ff.c ff.h ffconf.h integer.h
  group Self_c
    ../Self/src/: Imageprocess.c rodeview.c pid.c BorderSearch.c SpeedControl.c DirectionControl.c SteerActuator.c motor.c Encoder.c param.c common_type.c CrossRode.c Cuver.c Rode_Mix.c Island.c Flash_Date.c
  group Self_h
    ../Self/inc/: Imageprocess.h rodeview.h pid.h TypeDef.h BorderSearch.h DirectionControl.h SteerActuator.h PinMap.h motor.h Encoder.h SpeedControl.h param.h
target SeekFree_MK60FX (ARM-ADS)
  device: MK60FX512xxx15 Freescale
  cpu: IROM(0x00000000,0x80000) IROM2(0x10000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SeekFree_Kinetis
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MK60FX
  c include: ..\USER\inc;..\USER\src;..\..\Libraries\startup\CoreSupport;..\..\Libraries\startup\DeviceSupport\MDK-ARM;..\..\Libraries\startup\DeviceSupport;..\..\Libraries\drives\inc;..\..\Libraries\drives\src;..\..\Libraries\seekfree;..\..\Libraries\FatFs;..\..\Libraries\FatFs\option
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x20000
